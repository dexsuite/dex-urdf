Commit message: [fix] fix leap hand left

File: robots/hands/leap_hand/leap_hand_left_glb.urdf (robot description, URDF)
Before this commit: robot leap_left, 22 links, 21 joints
Links:
- link palm_lower_left: geometry collision box size=0.004 0.036 0.034; collision box size=0.01 0.12 0.02
